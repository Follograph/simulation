Commit message: 0226

File: resources/flexiv_test.urdf (robot description, URDF)
Before this commit: robot rizon4, 23 links, 22 joints
Joints:
- joint flexiv_hand_joint: origin xyz=0 0 0.107 rpy=0 0 -0.785398163397 -> xyz=0 0 0 rpy=0 0 0
